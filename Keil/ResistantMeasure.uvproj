# Keil uVision project ResistantMeasure.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5616AD STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x3FFF) CLOCK(45000000)
  output: ResistantMeasure +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ../Src/: Key.c LCD1602.c ResistantMeasure.c RM.c Timer.c Key.h LCD1602.h RM.h STC12C.h Timer.h Menu.h Menu.c CalcR.h CalcR.c
